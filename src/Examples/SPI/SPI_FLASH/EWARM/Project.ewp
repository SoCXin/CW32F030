# IAR project Project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32F030C8 WHXY CW32F030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CW32L083 CW32L083
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\CW\cw32l083.icf
  group Retarget
    ../../../../Utilities/: write.c
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32f030_gpio.c cw32f030_rcc.c cw32f030_spi.c cw32f030_uart.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32f030.s
    ../../../../Libraries/src/: system_cw32f030.c
  group User
    ../USER/src/: cw32_eval_spi_flash.c interrupts_cw32f030.c main.c
